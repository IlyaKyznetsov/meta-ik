SUMMARY = "Freescale Image"

LICENSE = "MIT"
